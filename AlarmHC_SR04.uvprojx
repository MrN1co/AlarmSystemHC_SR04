# Keil uVision project AlarmHC_SR04.uvprojx, settings and files
target FRDM-KL05ZJ (6160000::V6.16::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AlarmHC_SR04
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: main.c frdm_bsp.h
    ./: out
  group Display
    ./: lcd1602.c
  group Tsi
    ./: tsi.c
  group Keyboard
    ./: klaw.c
  group Speaker
    ./: DAC.c
  group I2C
    ./: i2c.c
  group Leds
    ./: leds.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
